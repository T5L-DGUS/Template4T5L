# Keil uVision project T5L51.uvproj, settings and files
target Target 1 (MCS-51)
  device: T5 DWIN
  cpu: IRAM(0-0xFF) CLOCK(24000000) MODC2 PMW DPC BSE MDU_R515
  output: T5L51 +hex
  AfterMake: D:\Work\0.项目\29.毛逗&智能宠物仓项目\C51\Template4T5L\Template4T5L\project\1.bat
  c flags: Optimize=8 SizeSpeed=1
  c define: _RX_TEST _USE_POLL _JPGTEST
  c include: ..\include;..\source;..\user;..\modules;..\project;..\include\T5L
  asm include: ..\include;..\source;..\user;..\modules;..\modules;..\project;..\include\T5L
  link misc: REMOVEUNUSED
  group include
    ./: STARTUP_M5.A51
    ../include/: sys.c sys.h
    ../include/T5L/: t5los8051.h T5LOSConfig.h
  group source
    ../source/: gpio.c gpio.h uart.c uart.h timer.c timer.h modbus.c modbus.h i2c.c i2c.h TA_protocal.c TA_protocal.h
  group user
    ../user/: main.c
  group modules
    ../modules/: rtc.c rtc.h boot_handoff.c boot_handoff.h v851_protocol.c v851_protocol.h v851_control_info.c v851_control_info.h v851_tlv_app.c v851_wifi.c v851_wifi.h t5l_stc.c QR_Encode.c QR_Encode.h qr_page.c qr_page.h
